# IAR project rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\libs; ..\MKL46Z4; ..\source\drivers; ..\source\modules; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: rtos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c
  group source/drivers
    ../source/drivers/: Board.h GPIO.h PIT.h Port.h Systick.h
  group source/modules
    ../source/modules/: os.c os.h os_config.h Timer.c Timer.h Timer_config.h
  group startup
    ../MKL46Z4/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
